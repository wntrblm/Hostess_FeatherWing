# Repository wntrblm/Hostess_FeatherWing

File README.md:

# Winterbloom Hostess FeatherWing

**:warning: Hostess is *extremely* experimental at this stage. It is not ready for prime time. I welcome folks who want to help out and poke around, but please do not expect anything here to work or make sense. Please reach out to me at me@thea.codes if you're interesting in helping out.**

Hostess is a [FeatherWing](https://learn.adafruit.com/adafruit-feather/featherwings) that provides a USB host co-processor. The FeatherWing handles all USB Host related tasks, including enumeration **and running the device drivers**, and communicates with the primary processor over [SPI](https://learn.adafruit.com/circuitpython-basics-i2c-and-spi/spi-devices). This means the primary processor can communicate with USB devices with minimal software and CPU time.

For example, a [CircuitPython](https://circuitpython.org)-based board could communicate with a USB MIDI device with minimal code:

```python
_spi = busio.SPI(board.SCK, MOSI=board.MOSI, MISO=board.MISO)
spi = SPIDevice(_spi, digitalio.DigitalInOut(board.D9), phase=1, polarity=0, baudrate=8000000)
hostess_midi_in = HostessMidiPortIn(spi)

while True:
    midi_event = hostess_midi_in.read()

    if midi_event is not None:
        print(midi_event)
```

Presently, Hostess has basic support for the following USB devices:

* MIDI
* Keyboard

And in-progress support for the following devices:

* PS4 controller

And I hope to add support for these devices eventually:

* USB Serial (CDC)
* Generic HID Gamepad
* Mouse

## Hardware

Hostess's [hardware](hardware) is based around the [Atmel SAMD21](https://www.microchip.com/wwwproducts/en/ATsamd21g18), a low-cost 32-bit ARM microcontroller with USB host capabilities. It incorporates a USB current-limiting switch to prevent devices from drawing too much current and provides the proper amount of capacitance for powering USB devices. This makes it a bit more robust compared to using an OTG adapter with existing development boards.

Hostess's hardware is the most complete part of the project. PCBs can be manufactured at OSHPark or other fabs and all of the components on the BOM are readily available at Mouser and DigiKey.

To upload the firmware and debug the device, you'll need a [SOICBite](https://github.com/SimonMerrett/SOICbite) and a J-Link or similar.

## Firmware

Hostess's [firmware](firmware) is written in C using [Atmel START](https://start.atmel.com/). Presently building it requires [Atmel Studio 7](https://www.microchip.com/mplab/avr-support/atmel-studio-7), though I'd like to switch to a Makefile.

## Library

Communicating with Hostess is the most incomplete part of the project. Presently, there is just an [example file](library/circuitpython.py) on how to communicate with it from CircuitPython. I'd like to make this a complete library as well as create an Arduino library.

## License and contributing

The code here is available under the [MIT License](firmware/LICENSE), the hardware designs are available under [CC BY-SA 4.0](hardware/LICENSE). I welcome contributors, please read the [Code of Conduct](CODE_OF_CONDUCT.md) first. :)

## KiCad design hardware/Hostess Feather.kicad_pcb

Parts:
C1: 1uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder; mpn MF-CAP-0805-1uF
C2, C3, C4, C8: 0.1uF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder; mpn MF-CAP-0805-0.1uF
C5, C6: 22pF; C_0805_2012Metric_Pad1.15x1.40mm_HandSolder; mpn MF-CAP-0603-22pF
C7: 100uF; C_1206_3216Metric_Pad1.42x1.75mm_HandSolder; mpn GRM31CR61A107ME05L
D1: Connected; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder; mpn MF-LED-0805-GREEN
D2: Read; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder; mpn MF-LED-0805-GREEN
D3: Write; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder; mpn MF-LED-0805-RED
J1: USB_A; USB_A_Stewart_SS-52100-001_Horizontal; mpn SS-52100-001
J2: CON_01X16_PTH_2.54MM; MF_Connectors-PTH_2.54MM_01X16
J3: CON_01X12_PTH_2.54MM; MF_Connectors-PTH_2.54MM_01X12
J4: SOICBite; SOIC_clipProgSmall
JP1, JP2, JP5, JP6, JP7: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
JP3, JP4: SolderJumper_2_Bridged; SolderJumper-2_P1.3mm_Bridged_Pad1.0x1.5mm
R1, R2, R3: 1k; R_0805_2012Metric_Pad1.15x1.40mm_HandSolder; mpn MF-RES-0805-1K
U1: ATSAMD21G18A-AUT; TQFP-48_7x7mm_P0.5mm; mpn ATSAMD21G18A-AUT
U2: TPS2051CDBV; SOT-23-5_HandSoldering; mpn TPS2051CDBV
Y1: Crystal; Crystal_SMD_2012-2Pin_2.0x1.2mm_HandSoldering; mpn ABS06-32.768KHz-1-T

Connections:
+3V3: C1.1, C2.1, C3.1, C4.1, J2.2 (PIN2), J4.1, U1.6 (VDDANA), U1.17 (VDDIO), U1.36 (VDDIO), U1.44 (VDDIN)
CONNECTED_LED: R1.1, U1.4 (PA03)
D5: J3.10 (PIN10), JP1.1 (A)
D6: J3.9 (PIN9), JP2.1 (A)
D9: J3.8 (PIN8), JP3.1 (A)
D10: J3.7 (PIN7), JP4.1 (A)
D11: J3.6 (PIN6), JP5.1 (A)
D12: J3.5 (PIN5), JP6.1 (A)
D13: J3.4 (PIN4)
D+: J1.3 (D+), U1.34 (PA25)
D-: J1.2 (D-), U1.33 (PA24)
FAULT: U1.25 (PA16), U2.3
GND: C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, D1.1 (K), D2.1 (K), D3.1 (K), J1.4 (GND), J1.5 (Shield), J2.4 (PIN4), J2.16 (PIN16), J4.4, U1.5 (GNDANA), U1.18 (GND), U1.35 (GND), U1.42 (GND), U2.2
MISO: J2.13 (PIN13), U1.21 (PA12)
MOSI: J2.12 (PIN12), U1.19 (PB10)
unnamed: C1.2, U1.43 (VDDCORE)
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R2.2
unnamed: D3.2 (A), R3.2
READ_LED: R2.1, U1.10 (PA05)
RESET: J4.8, JP2.2 (B), JP4.2 (B), JP6.2 (B), U1.40 (~RESET)
RX: J4.2, U1.16 (PA11)
SCK: J2.11 (PIN11), U1.20 (PB11)
SS: JP1.2 (B), JP3.2 (B), JP5.2 (B), U1.8 (PB09)
SWCLK: J4.7, U1.45 (PA30)
SWDIO: J4.5, U1.46 (PA31)
TX: J4.3, U1.15 (PA10)
VBUSEN: U1.24 (PA15), U2.4
VBUS_FILTERED: C7.1, C8.1, J1.1 (VBUS), JP7.1 (A), U2.1
VUSB: J3.3 (PIN3), JP7.2 (B), U2.5
WRITE_LED: R3.1, U1.12 (PA07)
XIN: C5.1, U1.1 (PA00), Y1.1
XOUT: C6.1, U1.2 (PA01), Y1.2

Notes on the sheet:
Blue
Green
Yellow or Red
Possible future enhancement: ESD (USBLC6)

Board: 2 copper layers, 50.8 x 22.9 mm, 29 parts (7 on the bottom side), 32 nets.

Other parts of the board:
Ref**: Val**; decal

## Code that names these connections

File MIDIHeart/driver_init.c (part):

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void TARGET_IO_PORT_init(void)
{

	gpio_set_pin_function(PA10, PINMUX_PA10C_SERCOM0_PAD2);

	gpio_set_pin_function(PA11, PINMUX_PA11C_SERCOM0_PAD3);
}

void TARGET_IO_CLOCK_init(void)
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void SPI_0_PORT_init(void)
{

	gpio_set_pin_level(PA12,
	                   // <y> Initial level
	                   // <id> pad_initial_level
	                   // <false"> Low
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	                   false);

	// Set pin direction to output
	gpio_set_pin_direction(PA12, GPIO_DIRECTION_OUT);

	gpio_set_pin_function(PA12, PINMUX_PA12D_SERCOM4_PAD0);

	// Set pin direction to input
	gpio_set_pin_direction(PB09, GPIO_DIRECTION_IN);

	gpio_set_pin_pull_mode(PB09,
	                       // <y> Pull configuration
	                       // <id> pad_pull_config
	                       // <GPIO_PULL_OFF"> Off
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	                       // <GPIO_PULL_DOWN"> Pull-down
	                       GPIO_PULL_OFF);

	gpio_set_pin_function(PB09, PINMUX_PB09D_SERCOM4_PAD1);

	// Set pin direction to input
	gpio_set_pin_direction(PB10, GPIO_DIRECTION_IN);

	gpio_set_pin_pull_mode(PB10,
	                       // <y> Pull configuration
	                       // <id> pad_pull_config
	                       // <GPIO_PULL_OFF"> Off
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	                       // <GPIO_PULL_DOWN"> Pull-down
	                       GPIO_PULL_OFF);

	gpio_set_pin_function(PB10, PINMUX_PB10D_SERCOM4_PAD2);

	gpio_set_pin_level(PB11,
	                   // <y> Initial level
	                   // <id> pad_initial_level
	                   // <false"> Low
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	                   false);

	// Set pin direction to output
	gpio_set_pin_direction(PB11, GPIO_DIRECTION_OUT);

	gpio_set_pin_function(PB11, PINMUX_PB11D_SERCOM4_PAD3);
}

void SPI_0_CLOCK_init(void)
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void USB_0_PORT_init(void)
{

	gpio_set_pin_direction(PA24,
	                       // <y> Pin direction
	                       // <id> pad_direction
	                       // <GPIO_DIRECTION_OFF"> Off
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	                       // <GPIO_DIRECTION_OUT"> Out
	                       GPIO_DIRECTION_OUT);

	gpio_set_pin_level(PA24,
	                   // <y> Initial level
	                   // <id> pad_initial_level
	                   // <false"> Low
	                   // <true"> High
	                   false);

	gpio_set_pin_pull_mode(PA24,
	                       // <y> Pull configuration
	                       // <id> pad_pull_config
	                       // <GPIO_PULL_OFF"> Off
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	                       // <GPIO_PULL_DOWN"> Pull-down
	                       GPIO_PULL_OFF);

	gpio_set_pin_function(PA24,
	                      // <y> Pin function
	                      // <id> pad_function
	                      // <i> Auto : use driver pinmux if signal is imported by driver, else turn off function
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	                      // <GPIO_PIN_FUNCTION_H"> H
	                      PINMUX_PA24G_USB_DM);

	gpio_set_pin_direction(PA25,
	                       // <y> Pin direction
	                       // <id> pad_direction
	                       // <GPIO_DIRECTION_OFF"> Off
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	                       // <GPIO_DIRECTION_OUT"> Out
	                       GPIO_DIRECTION_OUT);

	gpio_set_pin_level(PA25,
	                   // <y> Initial level
	                   // <id> pad_initial_level
	                   // <false"> Low
	                   // <true"> High
	                   false);

	gpio_set_pin_pull_mode(PA25,
	                       // <y> Pull configuration
	                       // <id> pad_pull_config
	                       // <GPIO_PULL_OFF"> Off
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	                       // <GPIO_PULL_DOWN"> Pull-down
	                       GPIO_PULL_OFF);

	gpio_set_pin_function(PA25,
	                      // <y> Pin function
	                      // <id> pad_function
	                      // <i> Auto : use driver pinmux if signal is imported by driver, else turn off function
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{
	init_mcu();

	// GPIO on PA03

	gpio_set_pin_level(CONNECTED_LED_PIN,
	                   // <y> Initial level
	                   // <id> pad_initial_level
	                   // <false"> Low
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	                   true);

	// Set pin direction to output
	gpio_set_pin_direction(CONNECTED_LED_PIN, GPIO_DIRECTION_OUT);

	gpio_set_pin_function(CONNECTED_LED_PIN, GPIO_PIN_FUNCTION_OFF);

	// GPIO on PA05

	gpio_set_pin_level(READ_LED_PIN,
	                   // <y> Initial level
	                   // <id> pad_initial_level
	                   // <false"> Low
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	                   true);

	// Set pin direction to output
	gpio_set_pin_direction(READ_LED_PIN, GPIO_DIRECTION_OUT);

	gpio_set_pin_function(READ_LED_PIN, GPIO_PIN_FUNCTION_OFF);

	// GPIO on PA07

	gpio_set_pin_level(WRITE_LED_PIN,
	                   // <y> Initial level
	                   // <id> pad_initial_level
	                   // <false"> Low
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	                   true);

	// Set pin direction to output
	gpio_set_pin_direction(WRITE_LED_PIN, GPIO_DIRECTION_OUT);

	gpio_set_pin_function(WRITE_LED_PIN, GPIO_PIN_FUNCTION_OFF);

	// GPIO on PA15

	gpio_set_pin_level(VUSB_EN_PIN,
	                   // <y> Initial level
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
## Commit log

2020-05-03 Initial version
    Basic working USB Midi host that re-transmit MIDI events over UART serial.
    No error handling yet.
2020-05-03 Add spi slave from Atmel Start
2020-05-04 Remove jlink.log
2020-05-06 Basic SPI slave MIDI events working
2020-05-06 Add some basic error handling to the enumeration process
2020-05-06 Add basic handling of device disconnection
2020-05-06 Single driver assignment
2020-05-06 Address a few TODOs
2020-05-06 Address a few more TODOs
2020-05-06 Fix queue assertion
2020-05-08 Add basic SPI Command set
2020-05-09 Basic HID driver, no parsing yet
2020-05-09 Basic ascii mapping
2020-05-10 Add basic keystring support
2020-05-10 Add shifting support
2020-05-11 Add SPI commands for getting the keystring
2020-05-11 Fix pipe teardown by adding abort()
2020-05-11 Fix an enumeration name
2020-05-11 Add SOF-based delay to avoid blocking
2020-05-11 Make keyboard driver properly poll using the endpoint interval
2020-05-11 Add some missing `static` declarations
2020-05-11 Add clang-format
2020-05-11 Fix some issues identified by clang-tidy
2020-05-12 Add control key event handling
2020-05-12 Add locking key handling
2020-05-13 Remove unused handle_ctrl_pipe
2020-05-26 Add wtr_utils
2020-05-26 Add pins for LEDs and current-limit switch on v0 hardware
2020-05-26 Make connected LED work
2020-05-26 Get read led to work
2020-05-28 Add hostess_status_leds to manage LED states
2020-05-28 Add startup LED animation
2020-05-28 Fix some small bugs with the LED animation
2020-05-28 Switch to async SPI
2020-05-28 Fix use-after-free error
2020-05-29 Add nack limit to ASF4 usb host code
2020-05-29 Fix uninitalized variable
2020-05-29 Add start of frame callbacks for host drivers
2020-05-29 Add MIDI out
2020-05-31 Make the midi in poll re-schedule itself, rather than doing it every frame
2020-05-31 Add queue overflow behavior
2020-05-31 format
2020-06-01 * Disable interrupts during the SPI response procedure. * Raise the nack limit for MIDI in, since it was way too low. * Add MIDI debug for the time being to debug dropped messages/stuck keys.
2020-06-02 Use goto/labeel to properly exit the pipe in method
2020-06-02 Add external interrupt controller
2020-06-03 Don't prevent setting LED state during the startup animation
2020-06-03 Move all the command processing to hostess_command_processor.
2020-06-03 Fix a comment style
2020-06-03 Remove vbus control/vbus fault stuff from wtr_usb_host, make it the responsibility of the application
2020-06-03 s/tabs/spaces
2020-06-05 Add null checks in the command parser
2020-06-05 s/_print_bytes/print_bytes
2020-06-05 Add unfinished PS4 controller driver
2020-06-08 Change SPI slow clock
2020-06-08 Add wtr_debug to easily disable printf throughout
2020-06-09 Add DMAC configuration
2020-06-09 Got DMA working for the first time
2020-06-18 Stat moving spi dma stuff into wtr_spi_dma
2020-06-18 Rename project/solution
2020-06-18 Rename files
2020-06-18 Clean up a bit of code
2020-06-18 Move firmware into its own folder
2020-06-18 Add hardware
2020-06-18 Add CircuitPython example
2020-06-18 Add README & LICENSE
2020-06-18 Remove unneeded file
2020-06-18 Fixup Atmel START config
2020-06-20 The DMA hack shall remain
2020-06-20 Fixup some function names to be more consistent
2020-06-20 Fix interrupt priority
